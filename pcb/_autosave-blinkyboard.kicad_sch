File: pcb/_autosave-blinkyboard.kicad_sch (KiCad schematic)
At the start: 17 parts, among them U1 4017, U2 NE555P

Commit message: p
Other:
- moved on the sheet: C1, C2, R2, RV1, U2
